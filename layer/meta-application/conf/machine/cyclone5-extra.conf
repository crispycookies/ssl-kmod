## layer/meta-application/conf/machine/cyclone5-extra.conf
```bitbake
UBOOT_CONFIG[de1-soc] = "socfpga_de1_soc_defconfig"
KERNEL_DEVICETREE_cyclone5_append = " socfpga_cyclone5_de1_soc.dtb "
```
